# IAR project 02_exti.ewp, settings and files
configuration es32w3120 (ARM, debug)
  General.OGChipSelectEditMenu: ES32W3120NK Eastsoft ES32W3120NK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_ASSERT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\Inc; ..\..\..\..\..\..\Drivers\ALD\ES32W3120\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include\ES32W3120; ..\Src; ..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: es32w3120.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ASSERT
  ICCARM.CCOptLevel: 3
  group doc
    ../: ReadMe.txt
  group startup
    ../../../../../../Drivers/CMSIS/Device/EastSoft/ES32W3120/Startup/iar/: startup_es32w3120.s
  group ald
    ../../../../../../Drivers/ALD/ES32W3120/Source/: ald_bkpc.c ald_cmu.c ald_gpio.c ald_pmu.c utils.c
  group app
    ../Src/: irq.c main.c
