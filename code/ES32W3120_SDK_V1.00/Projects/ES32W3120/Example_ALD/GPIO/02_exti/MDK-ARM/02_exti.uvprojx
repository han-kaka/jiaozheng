# Keil uVision project 02_exti.uvprojx, settings and files
target target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ESW3120NQ Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_ASSERT
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include\ES32W3120;..\..\..\..\..\..\Drivers\ALD\ES32W3120\Include;..\Src;..\Inc;..\..\..\..\..\..\Middlewares\Third_Party\RTT;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Log\Include;..\app;..\bsp;..\task
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../Src/: irq.c main.c
    ../Inc/: main.h global.h ald_conf.h sdk_conf.h
    ../app/: app_ble.c app_ble.h app_common.c app_common.h
  group bsp
    ../bsp/: bsp_common.c bsp_common.h bsp_dx_bt24_t.c bsp_dx_bt24_t.h bsp_flash.c bsp_flash.h bsp_led.c bsp_led.h bsp_motor.c bsp_motor.h bsp_power.c bsp_power.h bsp_system.c bsp_system.h bsp_time.c bsp_time.h bsp_mpu6050.c bsp_mpu6050.h
  group task
    ../task/: task_bluetooth.c task_bluetooth.h task_common.c task_common.h task_communicate.c task_communicate.h task_control.c task_control.h task_measure.c task_measure.h task_mem_read.c task_mem_read.h task_mem_write.c task_mem_write.h task_other.c task_other.h task_safeguard.c task_safeguard.h
  group startup
    ../../../../../../Drivers/CMSIS/Device/EastSoft/ES32W3120/Startup/keil/: startup_es32w3120.s
  group ald
    ../../../../../../Drivers/ALD/ES32W3120/Source/: ald_bkpc.c ald_cmu.c ald_gpio.c ald_pmu.c utils.c ald_i2c.c ald_dma.c ald_timer.c ald_uart.c ald_adc.c ald_pis.c ald_spi.c
    ../../../../../../Drivers/ALD/ES32W3120/Include/: ald_i2c.h ald_dma.h ald_timer.h ald_uart.h ald_adc.h ald_pis.h ald_spi.h
  group doc
    ../: ReadMe.txt
  group eslog
    ../../../../../../Middlewares/EastSoft/BLE5.0/Log/Source/: eslog_init.c eslog_printf_format.c eslog_uart.c
    ../../../../../../Middlewares/EastSoft/BLE5.0/Log/Include/: eslog_init.h eslog_printf_format.h eslog_uart.h
  group RTT
    ../../../../../../Middlewares/Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
